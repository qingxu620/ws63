# Keil uVision project ceshi.uvproj, settings and files
target QD-TFT (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: ceshi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SPI;..\font;..\GUI;..\LCD;..\sys;..\touch;..\USER
  group USER
    ../GUI/: gui.c
    ../USER/: main.c test.c
  group SYSTEM
    ../sys/: sys.c
  group HARDWARE
    ../LCD/: LCD.c
    ../touch/: ctpiic.c ft6336.c touch.c
    ../SPI/: SPI.c
