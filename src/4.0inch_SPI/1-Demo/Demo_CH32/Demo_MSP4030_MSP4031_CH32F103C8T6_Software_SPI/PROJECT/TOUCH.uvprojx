# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH32F103C8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\USER;..\CORE;..\CH32F10x_FWLib\inc;..\SYSTEM\Debug;..\HARDWARE\FLASH;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\TOUCH
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c ch32f10x_it.c system_ch32f10x.c GUI.c test.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/TOUCH/: touch.c ctpiic.c ft6336.c
  group CORE
    ../CORE/: core_cm3.c startup_ch32f10x.s
  group FWLib
    ../CH32F10x_FWLib/src/: ch32f10x_gpio.c ch32f10x_misc.c ch32f10x_rcc.c ch32f10x_spi.c ch32f10x_flash.c ch32f10x_usart.c
  group SYSTEM
    ../SYSTEM/Debug/: debug.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
