# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH32F203C8 WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\USER;..\CORE;..\SYSTEM\Debug;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\CH32F20x_FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c GUI.c test.c ch32f20x_it.c system_ch32f20x.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/TOUCH/: touch.c ctpiic.c ft6336.c
  group CORE
    ../CORE/: core_cm3.c startup_ch32f20x_D6.s
  group FWLib
    ../CH32F20x_FWLib/src/: ch32f20x_flash.c ch32f20x_gpio.c ch32f20x_misc.c ch32f20x_rcc.c ch32f20x_spi.c ch32f20x_usart.c
  group SYSTEM
    ../SYSTEM/Debug/: debug.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
